# Keil uVision project notos_Infantry.uvprojx, settings and files
target notos (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ntos_sentry +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F427X,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\User;..\AHRS;..\FreeRTOS\include;..\Libraries\CMSIS;..\Libraries\FWLIB\inc;..\DSP\Include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\User\BSP\adc;..\User\BSP\buzzer;..\User\BSP\can;..\User\BSP\crc;..\User\BSP\delay;..\User\BSP\exit_init;..\User\BSP\flash;..\User\BSP\fric;..\User\BSP\laser;..\User\BSP\led;..\User\BSP\OLED;..\User\BSP\power_ctrl;..\User\BSP\rc;..\User\BSP\rng;..\User\BSP\spi;..\User\BSP\super_cap;..\User\BSP\sys;..\User\BSP\timer;..\User\BSP\usart;..\User\APP\CAN_receive;..\User\APP\DT7&DR16;..\User\APP\FreeRTOS_middleware;..\User\APP\Judge_System;..\User\APP\miniPC;..\User\APP\motor_control;..\User\APP\pid;..\User\APP\shoot;..\User\APP\user_lib;..\User\TASK\chassis_task;..\User\TASK\gimbal_task;..\User\TASK\communication_task;..\User\TASK\INS_task;..\User\TASK\start_task;..\User\TASK\detect_task;..\User\TASK\calibrate_task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../Libraries/startup/: startup_stm32f427xx.s
  group CMSIS
    ../Libraries/CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../Libraries/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group AHRS
    ../AHRS/: AHRS_middleware.c ist8310driver.c ist8310driver_middleware.c mpu6500driver.c mpu6500driver_middleware.c AHRS.h AHRS.lib
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group DSP
    ../DSP/: arm_cortexM4lf_math.lib
    ../DSP/Include/: arm_math.h
  group BSP
    ../User/BSP/adc/: adc.c
    ../User/BSP/buzzer/: buzzer.c
    ../User/BSP/can/: can.c
    ../User/BSP/crc/: crc.c
    ../User/BSP/delay/: delay.c
    ../User/BSP/exit_init/: exit_init.c
    ../User/BSP/flash/: flash.c
    ../User/BSP/fric/: fric.c
    ../User/BSP/laser/: laser.c
    ../User/BSP/led/: led.c
    ../User/BSP/OLED/: oled.c
    ../User/BSP/power_ctrl/: power_ctrl.c
    ../User/BSP/rc/: rc.c
    ../User/BSP/rng/: rng.c
    ../User/BSP/spi/: spi.c
    ../User/BSP/super_cap/: super_cap.c
    ../User/BSP/sys/: sys.c
    ../User/BSP/timer/: timer.c
    ../User/BSP/usart/: usart.c
  group main
    ../User/: main.c
  group APP
    ../User/APP/user_lib/: user_lib.c
    ../User/APP/CAN_receive/: CAN_receive.c
    ../User/APP/DT7&DR16/: RC_DT7.c
    ../User/APP/FreeRTOS_middleware/: FreeRTOS_middleware.c
    ../User/APP/Judge_System/: judge_system.c
    ../User/APP/miniPC/: miniPC.c
    ../User/APP/motor_control/: motor_control.c
    ../User/APP/pid/: pid.c
    ../User/APP/shoot/: shoot.c
  group TASK
    ../User/TASK/start_task/: start_task.c
    ../User/TASK/chassis_task/: chassis_task.c
    ../User/TASK/gimbal_task/: gimbal_task.c
    ../User/TASK/communication_task/: communication_task.c
    ../User/TASK/INS_task/: INS_task.c
    ../User/TASK/calibrate_task/: calibrate_task.c
    ../User/TASK/detect_task/: detect_task.c
